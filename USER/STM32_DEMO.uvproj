# Keil uVision project STM32_DEMO.uvproj, settings and files
target STM32_DEMO (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\Unit_Code;.\usr_src;..\FWlib;..\SYS;..\Driver;..\FWlib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group User
    ./usr_src/: main.c
  group Driver
    ../Driver/: stm32f10x_it.c
  group SYS
    ../SYS/: wdg.c delay.c debug.c
  group FWlib
    ../FWlib/: STM32_F103_Lib.lib
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
